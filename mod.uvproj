# Keil uVision project mod.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5616AD STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x3FFF) CLOCK(45000000)
  output: mod +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./src/: led_time_2.c serial_port.c key.c
